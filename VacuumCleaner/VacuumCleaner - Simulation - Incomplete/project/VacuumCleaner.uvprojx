# Keil uVision project VacuumCleaner.uvprojx, settings and files
target STM32F411 (6140001::V6.14.1::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VaccumCleaner
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER SW_SIM=1 SIM=1
  c include: ..\source\Core;..\source\Drivers\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../source/Core/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Drivers
    ../source/Drivers/: startup_stm32f411xe.s stm32f4xx.h stm32f411xe.h system_stm32f4xx.c system_stm32f4xx.h
    ../source/Drivers/Src/: stm32f4xx_ll_tim.c stm32f4xx_ll_gpio.c stm32f4xx_ll_usart.c stm32f4xx_ll_rcc.c
  group Main
    ../source/Main/: main.c main.h
  group Modules
    ../source/Modules/: Display.c Display.h Led.c Led.h SW.c SW.h Timer.c Timer.h Uart.c Uart.h Motor.c Motor.h VC.c VC.h
    ../../VacuumCleaner - Simulation - complete/source/Modules/: Timer2.c Timer2.h
  group Port
    ../source/Port/: Port.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
